# IAR project QuickStart.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: C:\Users\7010master\Documents\IoT_Device_Dev\Cortex-M3\STM32_Nucleo_FW_V1.2.1\Libraries\CMSIS\Device\ST\STM32F10x\Include; C:\Program Files\IAR Systems\Embedded Workbench 8.0\arm\CMSIS\Include; C:\Users\7010master\Documents\IoT_Device_Dev\Cortex-M3\STM32_Nucleo_FW_V1.2.1\Libraries\STM32F10x_StdPeriph_Driver\inc; C:\Users\7010master\Documents\IoT_Device_Dev\Cortex-M3
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f103xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
    STM32_Nucleo_FW_V1.2.1/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c
